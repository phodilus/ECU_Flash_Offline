# Keil uVision project CAN1221.uvprojx, settings and files
target CAN1221 (ARM-ADS)
  device: STM32F207ZGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(120000000) ELITTLE
  output: CAN1221 +hex
  c flags: Optim=1
  c define: STM32F2XX, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS\STM32F2xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\Board;..\..\Board\Common;..\..\Board\FATFS\;..\..\Board\FATFS\media
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ./: readme.txt main.h main.c stm32f2xx_it.h stm32f2xx_it.c process.c process.h
  group Board
    ../../Board/Common/: fonts.h fonts.c lcd_log_conf.h lcd_log.h lcd_log.c stm32_eval_legacy.h
    ../../Board/: stm322xg_eval.h stm322xg_eval.c stm322xg_eval_fsmc_onenand.h stm322xg_eval_fsmc_onenand.c stm322xg_eval_fsmc_psram.h stm322xg_eval_fsmc_psram.c stm322xg_eval_fsmc_sram.h stm322xg_eval_fsmc_sram.c stm322xg_eval_i2c_ee.h stm322xg_eval_i2c_ee.c stm322xg_eval_ioe.h stm322xg_eval_ioe.c stm322xg_eval_lcd.c stm322xg_eval_lcd.h stm322xg_eval_sdio_sd.h stm322xg_eval_sdio_sd.c
  group FatFs
    ../../Board/FATFS/: fatfs_readme.txt integer.h diskio.h diskio.c ffconf.h ff.h ff.c
    ../../Board/FATFS/option/: cc932.c cc936.c cc949.c cc950.c ccsbcs.c syscall.c unicode.c
  group Lib
    ../../Libraries/STM32F2xx_StdPeriph_Driver/inc/: stm32f2xx_conf.h misc.h stm32f2xx_adc.h stm32f2xx_can.h stm32f2xx_crc.h stm32f2xx_cryp.h stm32f2xx_dac.h stm32f2xx_dbgmcu.h stm32f2xx_dcmi.h stm32f2xx_dma.h stm32f2xx_exti.h stm32f2xx_flash.h stm32f2xx_fsmc.h stm32f2xx_gpio.h stm32f2xx_hash.h stm32f2xx_i2c.h stm32f2xx_iwdg.h stm32f2xx_pwr.h stm32f2xx_rcc.h stm32f2xx_rng.h stm32f2xx_rtc.h stm32f2xx_sdio.h stm32f2xx_spi.h stm32f2xx_syscfg.h stm32f2xx_tim.h stm32f2xx_usart.h stm32f2xx_wwdg.h
    ../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group Core
    ../../Libraries/CMSIS/Include/: arm_common_tables.h arm_math.h core_cm3.h core_cmFunc.h core_cmInstr.h
    ../../Libraries/CMSIS/STM32F2xx/Include/: stm32f2xx.h system_stm32f2xx.h
    ../../Libraries/CMSIS/STM32F2xx/Source/arm/: startup_stm32f2xx.s
    ../../Libraries/CMSIS/STM32F2xx/Source/: system_stm32f2xx.c
